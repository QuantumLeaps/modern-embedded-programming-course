# Keil uVision project lesson.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.cpp qassert.h shape.cpp rectangle.cpp rectangle.hpp shape.hpp circle.cpp circle.hpp
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
