# Keil uVision project lesson.uvprojx, settings and files
target dbg (6230000::V6.23::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-declaration-after-statement
  c include: .;..\ucos2\Source;..\ucos2\Ports\ARM-Cortex-M\ARMv6-M\ARM;..\nucleo-c031c6;..\CMSIS\Include
  asm define: Stack_Size=2048,Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: lesson.sct
  group Source
    ./: main.c bsp.c bsp.h uc_ao.c uc_ao.h
  group nucleo-c031c6
    ../nucleo-c031c6/: README.txt stm32c0xx.h stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h
    ../nucleo-c031c6/arm/: startup_stm32c031xx.s
  group CMSIS
    ../CMSIS/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm0plus.h
  group ucos2
    ../ucos2/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos2-port
    ../ucos2/Ports/ARM-Cortex-M/ARMv6-M/: os_cpu_c.c
    ../ucos2/Ports/ARM-Cortex-M/ARMv6-M/ARM/: os_cpu.h os_cpu_a.asm os_dbg.c
