# Keil uVision project ek-tm4c123gxl.uvprojx, settings and files
target dbg (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  AfterMake: fromelf --bin --output .\build_ek-tm4c123gxl\test.bin .\build_ek-tm4c123gxl\test.axf
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: .;..\src;..\..\..\et;..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group src
    ../src/: ring_buf.c ring_buf.h
  group test
    ./: bsp_ek-tm4c123gxl.c test_ring_buf.c
  group ET
    ../../../et/: et.c et.h
  group ek-tm4c123gxl
    ../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
    ../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
