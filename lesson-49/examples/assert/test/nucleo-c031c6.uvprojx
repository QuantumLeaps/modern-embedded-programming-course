# Keil uVision project nucleo-c031c6.uvprojx, settings and files
target dbg (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test
  AfterMake: fromelf --bin --output .\build_nucleo-c031c6\test.bin .\build_nucleo-c031c6\test.axf
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32C031xx
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: .;..\src;..\..\..\et;..\..\..\3rd_party\nucleo-c031c6
  asm define: Stack_Size=1024 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --entry Reset_Handler
  group src
    ../src/: div.c div.h
  group test
    ./: test.c bsp_nucleo-c031c6.c
  group ET
    ../../../et/: et.c et.h
  group nucleo-c031c6
    ../../../3rd_party/nucleo-c031c6/: stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h
    ../../../3rd_party/nucleo-c031c6/arm/: startup_stm32c031xx.s
