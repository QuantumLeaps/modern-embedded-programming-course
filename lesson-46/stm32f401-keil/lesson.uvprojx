# Keil uVision project lesson.uvprojx, settings and files
target dbg (6220000::V6.22::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: ../qpc/include;../qpc/ports/arm-cm/qv/armclang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\lesson.sct
  link misc: --entry Reset_Handler
  group Application
    ./: main.c bsp.c bsp.h
  group qpc
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../qpc/src/qv/: qv.c
  group qpc_port
    ../qpc/ports/arm-cm/qv/armclang/: qp_port.h qs_port.h qv_port.c
  group qpc_qs
    ../qpc/src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c
target spy (6220000::V6.22::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: ../qpc/include;../qpc/ports/arm-cm/qv/armclang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\lesson.sct
  link misc: --entry Reset_Handler
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
