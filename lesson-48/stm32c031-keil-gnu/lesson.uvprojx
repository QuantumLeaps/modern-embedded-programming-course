# Keil uVision project lesson.uvprojx, settings and files
target BuildConfig-dbg (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson
  group Source
    ./: main.c bsp.c bsp.h startup_stm32c031xx.c lesson.ld system_stm32c0xx.c
target BuildConfig-spy (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: lesson
software components: CMSIS:CORE 5.6.0, RTEF:Event Processor 7.3.0, RTEF:Framework 7.3.0, RTEF:Real-Time Kernel 7.3.0, RTEF:Software tracing 7.3.0
