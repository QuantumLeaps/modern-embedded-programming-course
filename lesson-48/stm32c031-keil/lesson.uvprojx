# Keil uVision project lesson.uvprojx, settings and files
target BuildConfig-dbg (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wno-declaration-after-statement
  c include: ..\qpc\include;..\qpc\ports\arm-cm\qv\armclang;..\qpc\3rd_party\nucleo-c031c6;..\qpc\3rd_party\CMSIS\Include
  asm define: Stack_Size=2048,Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\lesson.sct
  group Source
    ./: main.c bsp.c bsp.h
  group nucleo-c031c6
    ../qpc/3rd_party/nucleo-c031c6/: README.txt stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h
    ../qpc/3rd_party/nucleo-c031c6/arm/: startup_stm32c031xx.s
  group qpc
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../qpc/src/qv/: qv.c
  group qpc_port
    ../qpc/ports/arm-cm/qv/armclang/: qp_port.h qs_port.h qv_port.c
  group qs
    ../qpc/src/qs/: qs.c qs_rx.c qstamp.c
target BuildConfig-spy (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY
  c misc: -Wno-declaration-after-statement
  c include: as above
  asm define: Stack_Size=2048,Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\lesson.sct
