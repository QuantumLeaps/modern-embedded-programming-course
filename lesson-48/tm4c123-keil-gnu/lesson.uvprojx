# Keil uVision project lesson.uvprojx, settings and files
target BuildConfig-dbg (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  group Source
    ./: bsp.c main.c bsp.h lesson.ld startup_TM4C123GH6PM.c
target BuildConfig-spy (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: lesson
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1, RTEF:Event Processor 7.3.0, RTEF:Framework 7.3.0, RTEF:Real-Time Kernel 7.3.0, RTEF:Software tracing 7.3.0
