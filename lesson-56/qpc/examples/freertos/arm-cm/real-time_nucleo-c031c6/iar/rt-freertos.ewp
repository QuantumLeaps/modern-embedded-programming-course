# IAR project rt-freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32C031C6 ST STM32C031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32C031xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\include; ..\..\..\..\..\ports\freertos; ..\..\..\..\..\3rd_party\FreeRTOS-Kernel\include; ..\..\..\..\..\3rd_party\FreeRTOS-Kernel\portable\IAR\ARM_CM0; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\nucleo-c031c6
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: rt-freertos.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: rt-freertos.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32C031xx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STM32C031xx
  ICCARM.CCOptLevel: 1
  group FreeRTOS
    ../../../../../3rd_party/FreeRTOS-Kernel/: list.c queue.c tasks.c
    ../../../../../3rd_party/FreeRTOS-Kernel/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group nucleo-c031c6
    ../../../../../3rd_party/nucleo-c031c6/iar/: startup_stm32c031xx.s
    ../../../../../3rd_party/nucleo-c031c6/: stm32c031xx.h system_stm32c0xx.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    ../../../../../ports/freertos/: qf_port.c qp_port.h qs_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_rx.c qstamp.c
  group rt-freertoslication
    ../: bsp.c bsp.h FreeRTOSConfig.h main.c periodic1.c periodic4.c qp_config.h rt-freertos.h sporadic2.c sporadic3.c
