# Keil uVision project rt-qv-tt.uvprojx, settings and files
target rt-dbg (6220000::V6.22::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-qv-tt
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output=$H@P.bin $H@P.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qv\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-c031c6
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: rt-qv-tt.sct
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c app.h bsp.h main.c periodic1.c periodic4.c qp_config.h sporadic2.c sporadic3.c ttsched.c
  group nucleo-c031c6
    ../../../../../3rd_party/nucleo-c031c6/: stm32c0xx.h stm32c031xx.h system_stm32c0xx.c
    ../../../../../3rd_party/nucleo-c031c6/arm/: startup_stm32c031xx.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qv/: qv.c
  group QP_port
    ../../../../../ports/arm-cm/qv/armclang/: qs_port.h qv_port.c
target rt-rel (6220000::V6.22::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: rt-qv-tt
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output=$H@P.bin $H@P.axf
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\rt-qv-tt.sct
  link misc: --entry Reset_Handler
