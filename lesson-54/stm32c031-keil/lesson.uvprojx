# Keil uVision project lesson.uvprojx, settings and files
target dbg (6220000::V6.22::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c misc: -Wno-declaration-after-statement
  c include: .;..\qpc\include;..\qpc\ports\arm-cm\qv\armclang;..\nucleo-c031c6;..\CMSIS\Include
  asm define: Stack_Size=2048,Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: lesson.sct
  group Source
    ./: main.c bsp.c bsp.h app.h periodic1.c periodic4.c qp_config.h sporadic2.c sporadic3.c
  group nucleo-c031c6
    ../nucleo-c031c6/: README.txt stm32c0xx.h stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h
    ../nucleo-c031c6/arm/: startup_stm32c031xx.s
  group CMSIS
    ../CMSIS/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm0plus.h
  group qpc-qv
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qmact.c qf_qeq.c qf_time.c
    ../qpc/src/qv/: qv.c
    ../qpc/ports/arm-cm/qv/armclang/: qp_port.h qs_port.h qv_port.c
