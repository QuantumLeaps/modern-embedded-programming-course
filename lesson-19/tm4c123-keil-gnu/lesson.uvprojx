# Keil uVision project lesson.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson +hex
  AfterMake: objcopy -I ihex -O binary $H@P.hex $H@P.bin
  group Source
    ./: main.c bsp.c bsp.h
  group ek-tm4c123gxl
    ../ek-tm4c123gxl/gnu/: startup_TM4C123GH6PM.c
    ../ek-tm4c123gxl/: README.txt system_TM4C123.c system_TM4C123.h
