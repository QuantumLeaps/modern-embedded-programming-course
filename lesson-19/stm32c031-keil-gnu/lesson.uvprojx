# Keil uVision project lesson.uvprojx, settings and files
target Debug (6190000::V6.19::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lesson +hex
  AfterMake: objcopy -I ihex -O binary $H@P.hex $H@P.bin
  group Source
    ./: main.c bsp.c lesson.ld
  group nucleo-c031c6
    ../nucleo-c031c6/: README.txt stm32c0xx.h stm32c031xx.h system_stm32c0xx.c system_stm32c0xx.h
    ../nucleo-c031c6/gnu/: startup_stm32c031xx.c
