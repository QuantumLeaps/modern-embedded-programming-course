# Keil uVision project lesson.uvprojx, settings and files
target dbg (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .;..\smc\lib\c;..\ucos2\Source;..\ucos2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\CMSIS\Include;..\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: lesson.sct
  link misc: --entry Reset_Handler
  group Applicatioin
    ./: bsp.c main.c bsp.h os_cfg.h app_cfg.h README.md uc_ao.c uc_ao.h timebomb.sm timebomb_sm.c timebomb_sm.h
  group ek-tm4c123gxl
    ../ek-tm4c123gxl/: system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
    ../ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group ucos2
    ../ucos2/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos2-port
    ../ucos2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../ucos2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu.h os_cpu_a.asm os_dbg.c
