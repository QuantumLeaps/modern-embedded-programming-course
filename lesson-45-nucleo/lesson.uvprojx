# Keil uVision project lesson.uvprojx, settings and files
target dbg (6160000::V6.16::ARMCLANG)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: .;..\qpc\include;..\qpc\src;..\qpc\ports\arm-cm\qv\armclang;..\qpc\3rd_party\CMSIS\Include;..\qpc\3rd_party\nucleo-l152re
  asm define: Stack_Size=1024 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
  group Application
    ./: bsp.c main.c bsp.h
  group nucleo-l152re
    ../qpc/3rd_party/nucleo-l152re/: stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
    ../qpc/3rd_party/nucleo-l152re/arm/: startup_stm32l1xx.s
  group QPC
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../qpc/src/qv/: qv.c
  group QPC_port
    ../qpc/ports/arm-cm/qv/armclang/: qep_port.h qf_port.h qs_port.h qv_port.c qv_port.h
