# Keil uVision project lesson.uvprojx, settings and files
target BuildConfig-dbg (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: QP_CONFIG
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\lesson.sct
  link misc: --entry Reset_Handler
  group Source
    ./: bsp.c main.c bsp.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1, RTEF:Event Processor 7.3.0, RTEF:Framework 7.3.0, RTEF:Real-Time Kernel 7.3.0, RTEF:Software tracing 7.3.0
