# Keil uVision project lesson.uvprojx, settings and files
target dbg (6190000::V6.19::ARMCLANG)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -Wconditional-uninitialized -Wsometimes-uninitialized
  c include: ../nucleo-l152re
  asm define: Stack_Size=1024,Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
  group Application
    ./: main.c bsp.c bsp.h
  group nucleo-l152re
    ../nucleo-l152re/: README.txt stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
    ../nucleo-l152re/arm/: startup_stm32l1xx.s
software components: CMSIS:CORE 5.6.0, RTEF:Event Processor 7.3.0, RTEF:Framework 7.3.0, RTEF:Real-Time Kernel 7.3.0
