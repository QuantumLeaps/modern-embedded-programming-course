# Keil uVision project lesson.uvprojx, settings and files
target dbg (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .;..\qpc\3rd_party\FreeRTOS\Source\include;..\qpc\3rd_party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\qpc\src;..\qpc\ports\arm-cm\qxk\armclang;..\qpc\3rd_party\CMSIS\Include;..\qpc\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ./: bsp.c main.c bsp.h FreeRTOSConfig.h
  group ek-tm4c123gxl
    ../qpc/3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
    ../qpc/3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group FreeRTOS
    ../qpc/3rd_party/FreeRTOS/Source/: tasks.c queue.c list.c
    ../qpc/3rd_party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
